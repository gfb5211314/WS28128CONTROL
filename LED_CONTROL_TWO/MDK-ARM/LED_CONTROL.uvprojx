# Keil uVision project LED_CONTROL.uvprojx, settings and files
target LED_CONTROL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED_CONTROL +hex
  AfterMake: fromelf --bin --output C:\Users\Fubiao.Guo\Desktop\BESTBEW\LED_CONTROL_TWO\LED_CONTROL\MDK-ARM\LED_CONTROL\LED_CONTROL.BIN  C:\Users\Fubiao.Guo\Desktop\BESTBEW\LED_CONTROL_TWO\LED_CONTROL\MDK-ARM\LED_CONTROL\LED_CONTROL.AXF
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\BSP;    ..\APP;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c main.c freertos.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: bsp_usart.c bsp_rtc.c bsp_led.c bsp_ws2812.c crc.c stm_flash.c bsp_commun.c bsp_dma.c bsp_gpio.c bsp_tim.c bsp_update.c bsp_upgrade.c
  group APP
    ../APP/: esp8266.c ws2812_app.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c list.c tasks.c timers.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
